Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-11-27T16:43:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 27 16:43:40 2019 * Host: DLICA-RO-DE * Database: C:\Users\dlica\AppData\Local\Temp\{D1BA1ABE-7F60-4586-83F8-AC1DCC49844B}\ifc * Database version: 5507 * Database creation date: Wed Nov 27 16:43:38 2019 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Nov 27 16:43:38 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 27 16:43:38 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcLightFixture: LTA-CLO/FLX, E_Emergency Lighting Fixture_MEPcontent_VanLien_LUTIA_Wall Mounted_NL-EN:LTA-CLO/FLX:1378529
In: V00
Type - PredefinedType: POINTSOURCE; Material: Color RGB 102-102-102, Color RGB 180-180-180, Color RGB 235-235-235, Color RGB 080-080-080
Type - Dimensions - Depth: 80 mm; Height: 250 mm; Rotation U-Axis Correction: 90 deg; Rotation V-Axis Correction: 180 deg; Rotation W-Axis Correction: 0 deg; Width: 235 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC
Type - Electrical - Loads - Apparent Load: 5.5 W; Load Classification: Power
Type - Electrical Engineering - Voltage: 230 V
Type - Identity Data - Article Description: Slave 2 watt, 230 Volt surface mount led luminaire including daylight sensor, including control module; Article Type: LTA-CLO/FLX; Base Family Version: 12.07; Category: EL_LIGHTFIXTURE_SWITCHED; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Slave 2 watt, 230 Volt surface mount led luminaire including daylight sensor, including control module; EMCS Version: 4.0; ETIM Article Class: EC001957; Family Version: 12.07; GLN: 8713812000008; GTIN: 08713812770451; Manufacturer: VanLien; Manufacturer Art. No.: 65760253; Manufacturer URL: http://www.vanlien.nl/ps/fulltilt/vanlien.cgi?co=NL&lang=en&part=65760253; MEPcontent Class: EMERGENCY_LIGHTING_FIXTURE; Model: LTA-CLO/FLX; OmniClass Number: 23.80.70.11.21; OmniClass Title: Emergency Lighting; Product Line: VanLien; Revit Version: 2017; Type Name: LTA-CLO/FLX; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Lighting Fixtures; Family Name: E_Emergency Lighting Fixture_MEPcontent_VanLien_LUTIA_Wall Mounted_NL-EN
Type - Pset_LightFixtureTypeCommon - Reference: LTA-CLO/FLX
Pset_ManufacturerTypeInformation - Manufacturer: VanLien
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Offset: 0 mm
Dimensions - Area: 0.175771 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.00387881 m3
Electrical - Circuiting - Electrical Data: Power - Balanced 230 V/1-6 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Electrical - Loads - Power: 0 W
Identity Data - Design Option: Main Model; Function Code: E6350; Mark: 7
Other - Family: E_Emergency Lighting Fixture_MEPcontent_VanLien_LUTIA_Wall Mounted_NL-EN: LTA-CLO/FLX; Family and Type: E_Emergency Lighting Fixture_MEPcontent_VanLien_LUTIA_Wall Mounted_NL-EN: LTA-CLO/FLX; Type: E_Emergency Lighting Fixture_MEPcontent_VanLien_LUTIA_Wall Mounted_NL-EN: LTA-CLO/FLX; Type Id: E_Emergency Lighting Fixture_MEPcontent_VanLien_LUTIA_Wall Mounted_NL-EN: LTA-CLO/FLX
Phasing - Phase Created: 3. New Construction
